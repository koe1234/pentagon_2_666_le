# Keil uVision project pae_mcu.uvproj, settings and files
target PaE (ARM-ADS)
  device: LPC2368 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: pae_mcu +hex
  c flags: Optim=4
  c include: .\efsl\inc;.\usb;.\ps2;..\..\..\common\fatfs;.\sdcard;..\..\..\common\fatfs\option
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group main
    ./: pae_mcu.c LPC2300.s
  group rom
    ./: basic48.c basic128.c compress.c fatall.c fpga.c gluk.c logo.c trdos.c
  group usb
    ./usb/: hiduser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group ps2
    ./ps2/: ps2.c
  group sdcard
    ./sdcard/: lpc23xx_spi.c sd.c
  group fatfs
    ../../../common/fatfs/: ff.c
    ../../../common/fatfs/option/: ccsbcs.c
